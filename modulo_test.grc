options:
  parameters:
    author: benjamin
    generate_options: qt_gui
    id: modulo_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: mod
  id: variable_qtgui_range
  parameters:
    label: mod
    rangeType: int
    start: '1'
    step: '1'
    stop: '20'
    value: '1'
  states: {}
- name: mul
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mul
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: modulo_modulo_operator_0
  id: modulo_modulo_operator
  parameters:
    modulo: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', modulo_modulo_operator_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [modulo_modulo_operator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
